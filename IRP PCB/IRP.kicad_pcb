# Repository Azzazy/auc_robotics_IRB_electronics

File README.md:

# Electronics
## Basics of Electricity
### Why Electronics
### Closed circuit
### Sources
### Analog/Digital
### AC/DC
### Low/High Power
## Components, [list](https://github.com/Azzazy/ecng-ecea-famous-components)
### Basic 
#### Resistor
#### Capacitor
#### LED
#### Connector
#### Diode
### Advanced
#### Transistor, [amplify](https://www.instructables.com/id/Voltage-Amplifier/), [switch](https://learn.sparkfun.com/tutorials/transistors/applications-i-switches)
#### OpAmp, [online simulator](http://www.falstad.com/circuit/e-opamp.html)
#### Relay
#### Voltage Regulator
### Complex
## Circuits
### Motor Driver, [example](https://www.instructables.com/id/Two-Relay-DC-Motor-Control-Simple-H-bridge/)
### Arduino, [example](https://www.instructables.com/id/How-to-Build-an-Arduino-Uno-on-a-BreadBoard/)
### AC with Ardino, [example](https://electronics.stackexchange.com/questions/56520/using-a-tip122-to-control-a-motor)

## How to edit
Fork the repo and create a pull request with the changes

## KiCad design IRP PCB/IRP.kicad_pcb

Parts:
BT1: Conn_01x06; PINHEAD1-6
Battary1: Conn_01x02; PINHEAD1-2
C1, C2: C; CP_Radial_Tantal_D9.0mm_P5.00mm
D1, D2: D; D_A-405_P12.70mm_Horizontal
FTDI1: Conn_01x06; PINHEAD1-6
K1, K2: Relay; Relay_SPDT_SANYOU_SRD_Series_Form_C
Motor1: Conn_01x02; PINHEAD1-2
Q1, Q2: TIP122; TO-220-3_Vertical
R1, R2, R3: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P20.32mm_Horizontal
U1: LM7805_TO220; TO-220-3_Vertical
U2: ATMEGA328-MMH; DIP-28_W7.62mm_Socket
Y1: Crystal; Crystal_HC18-U_Vertical

Connections:
+5V: BT1.5, FTDI1.3, R3.1, U1.3 (VO), U2.7
+12V: Battary1.1, D1.1 (K), D2.1 (K), K1.2, K1.3, K2.3, K2.5, U1.1 (VI)
/HB1: R2.2, U2.12
/HB2: R1.2, U2.13
/RESET: FTDI1.6, R3.2, U2.1
/RX: BT1.2, FTDI1.5, U2.3
/TX: BT1.3, FTDI1.4, U2.2
GND: BT1.4, Battary1.2, C1.1, C2.1, FTDI1.1, K1.4, K2.4, Q1.3 (E), Q2.3 (E), U1.2 (GND), U2.8
unnamed: C1.2, U2.9, Y1.1
unnamed: C2.2, U2.10, Y1.2
unnamed: D1.2 (A), K2.2, Q2.2 (C)
unnamed: D2.2 (A), K1.5, Q1.2 (C)
unnamed: K1.1, Motor1.1
unnamed: K2.1, Motor1.2
unnamed: Q1.1 (B), R1.1
unnamed: Q2.1 (B), R2.1

Board: 2 copper layers, 73.1 x 86.6 mm, 18 parts (0 on the bottom side), 16 nets.

## Commit log

2018-09-27 PCB schematic
2018-09-27 new atmega
